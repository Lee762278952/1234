# Keil uVision project TS-8209A.uvprojx, settings and files
target TS-8209A (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TS-8209A +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_USB_OTG_FS
  c include: ..\APPLICATION;..\APPLICATION\APP_UI;..\CORE;..\OBJ;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\UCOS-BSP;..\UCOSIII\UCOS-CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\HARDWARE\IIC;..\HARDWARE\LCD;..\HARDWARE\SDIO;..\HARDWARE\SDRAM;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\W25QXX;..\HARDWARE\NAND;..\HARDWARE\FN6110R;..\SYSTEM\fatfs\doc\en;..\SYSTEM\fatfs\doc\img;..\SYSTEM\fatfs\doc\ja;..\SYSTEM\fatfs\exfuns;..\SYSTEM\fatfs\src;..\SYSTEM\malloc;..\SYSTEM\picture;..\SYSTEM\text;..\SYSTEM\usb\USB_FUNCTION;..\SYSTEM\usb\STM32_USB_HOST_Library\Class\MSC\inc;..\SYSTEM\usb\STM32_USB_HOST_Library\Core\inc;..\SYSTEM\usb\STM32_USB_OTG_Driver\inc;..\SYSTEM\input;..\SYSTEM\wifi;..\SYSTEM\lwip;..\SYSTEM\lwip\arch;..\SYSTEM\lwip\lwip-1.4.1\src\include;..\SYSTEM\lwip\lwip-1.4.1\src\include\ipv4;..\SYSTEM\lwip\lwip-1.4.1\src\include\netif;..\SYSTEM\lwip\lwip_app\lwip_comm;..\SYSTEM\lwip\lwip_app\tcp_client_demo;..\HARDWARE\pcf8574;..\HARDWARE\LAN8720;..\HARDWARE\ADC;..\HARDWARE\RTC;..\SYSTEM\power;..\SYSTEM\debug
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APPLICATION
    ../APPLICATION/: main.c Task.c stm32f4xx_it.c system_stm32f4xx.c sys_network.c sys_application.c sys_parameters.h
    ../APPLICATION/APP_UI/: app_ui.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group SYS_TEXT
    ../SYSTEM/text/: text.c
  group SYS_FATFS
    ../SYSTEM/fatfs/src/: diskio.c ff.c
    ../SYSTEM/fatfs/exfuns/: exfuns.c fattester.c mycc936.c
  group SYS_MALLOC
    ../SYSTEM/malloc/: malloc.c sys_malloc.c
  group SYS_PICTURE
    ../SYSTEM/picture/: bmp.c piclib.c tjpgd.c
  group SYS_USB
    ../SYSTEM/usb/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ../SYSTEM/usb/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../SYSTEM/usb/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../SYSTEM/usb/USB_FUNCTION/: usb_bsp.c usbh_usr.c usb_func.c
  group SYS_INPUT
    ../SYSTEM/input/: pyinput.c
  group SYS_WIFI
    ../SYSTEM/wifi/: wifi.c
  group SYS_LWIP
    ../SYSTEM/lwip/lwip_app/lwip_comm/: lwip_comm.c
    ../SYSTEM/lwip/lwip_app/tcp_client_demo/: tcp_client_demo.c
    ../SYSTEM/lwip/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
    ../SYSTEM/lwip/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../SYSTEM/lwip/arch/: sys_arch.c
    ../SYSTEM/lwip/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../SYSTEM/lwip/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group SYS_POWER
    ../SYSTEM/power/: power.c
  group SYS_DEBUG
    ../SYSTEM/debug/: sysdebug.c
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_eth.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c touch.c gt911.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/NAND/: ftl.c nand.c nandtester.c
    ../HARDWARE/FN6110R/: FN6110R.c
    ../HARDWARE/pcf8574/: pcf8574.c
    ../HARDWARE/LAN8720/: lan8720.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/RTC/: rtc.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS-BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_c.c os_cpu_a.asm
  group UCOSIII_CONFIG
    ../UCOSIII/UCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group README
    ../README/: Record.txt
